# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\HARDWARE\GAME;..\HARDWARE\BMP180;..\HARDWARE\ADC;..\HARDWARE\MQ-2;..\HARDWARE\DHT11;..\HARDWARE\MAX30102;..\HARDWARE\SDIO;..\HARDWARE\OV7725;..\FATFS\src;..\MALLOC;..\HARDWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ott2001a.c ft5206.c gt9147.c
    ../HARDWARE/BMP180/: bmp180.c
    ../HARDWARE/ADC/: adcx.c
    ../HARDWARE/MQ-2/: mq2.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/MAX30102/: max30102.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DAC/: dac.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c fat_cc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_tim.c
  group GAME
    ../HARDWARE/GAME/: game.c menu.c ui.c plane.c snake.c heart.c lock.c photo.c explorer.c dacapp.c
